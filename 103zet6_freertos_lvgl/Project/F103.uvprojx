# Keil uVision project F103.uvprojx, settings and files
target F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Drive\Source;..\Drive\Include;..\STM32\STM32F10x_StdPeriph_Driver\inc;..\MY;..\STM32\CMSIS\CM3\CoreSupport;..\STM32\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\FreeRTOS\inc;..\FreeRTOS\src;..\FreeRTOS\port;..\FreeRTOS\port\MemMang;..\LVGL\GUI;..\LVGL\GUI\lvgl\src;..\LVGL\GUI\lvgl;..\LVGL\GUI\porting;..\LVGL\GUI\lvgl\demos\benchmark\assets;..\LVGL\GUI\lvgl\demos;..\LVGL\GUI\lvgl\demos\benchmark
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MY
    ../MY/: main.c stm32f10x_it.c
  group Driver
    ../Drive/Source/: led.c key.c usart.c lcd_fonts.c lcd_image.c lcd_spi_154.c
  group STM32
    ../STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s startup_stm32f10x_hd.s
    ../STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../STM32/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c
  group FreeRTOS
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/port/: port.c
    ../FreeRTOS/port/MemMang/: heap_4.c
  group lvgl
    ../LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LVGL/GUI/lvgl/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../LVGL/GUI/lvgl/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    ../LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ../LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c
    ../LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../LVGL/GUI/porting/: lv_port_disp.c lv_port_indev.c
    ../LVGL/GUI/: lv_conf.h
    ../LVGL/GUI/lvgl/: lvgl.h
    ../LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group demos
    ../LVGL/GUI/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../LVGL/GUI/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
